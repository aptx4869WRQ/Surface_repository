# Keil uVision project Infantry_HZW.uvprojx, settings and files
target Infantry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry_HZW
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,MOTION_DRIVER_TARGET_MSP430,MPU9250
  c misc: --C99
  c include: ..\bsp\inc;..\core;..\driver\inc;..\lib\eMPL;..\lib\eMPL\custom;..\lib\freertos\inc;..\lib\std\inc;..\system\sim_IIC;..\task\inc;..\user;..\system\StringDecoding;..\oled
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c Config.h Handler.h
    ../lib/freertos/inc/: FreeRTOSConfig.h
  group driver
    ../driver/src/: Driver_Bell.c Driver_DBUS.c Driver_Judge.c Driver_vision.c Driver_Chassis.c Driver_Control.c Driver_ESP8266.c Driver_Steering.c Driver_mpu9250.c Driver_FricMotor.c Driver_PokeMotor.c Driver_CloudMotor.c Driver_StatusMachine.c Driver_SuperGyroscope.c
  group task
    ../task/src/: Task_Bell.c Task_Control.c Task_ESP8266.c Task_Monitor.c Task_CANSend.c Task_SysInitConfig.c
  group bsp
    ../bsp/src/: BSP_TIM.c BSP_CAN.c BSP_DMA.c BSP_NVIC.c BSP_GPIO.c BSP_UART.c
  group stdlib
    ../lib/std/src/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group freertos
    ../lib/freertos/src/: list.c port.c tasks.c timers.c queue.c heap_2.c croutine.c event_groups.c
  group dmp
    ../lib/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../lib/eMPL/custom/: mpu9250dmp.c
  group core
    ../core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group system
    ../system/sim_IIC/: sim_IIC.c
    ../system/StringDecoding/: StringDecoding.c
  group oled
    ../oled/: drv_gui.c bsp_oled.c
